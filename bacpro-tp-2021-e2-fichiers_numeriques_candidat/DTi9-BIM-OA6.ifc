Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-10-12T11:15:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180328_1600(x64) - Exporter 19.0.1.1 - Interface utilisateur alternative 19.0.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 12 11:15:34 2020 * Host: maison * Database: C:\Users\MICHAEL\AppData\Local\Temp\{CFA63875-9A82-4EB1-85AF-9C9721B06496}\ifc * Database version: 5507 * Database creation date: Mon Oct 12 11:14:46 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 12 11:14:47 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 12 11:14:47 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Name | LongName | Elevation (m)
Niveau 1 | Niveau 1 | 0
Niveau 2 | Niveau 2 | 4

# IfcBuildingElementProxy: Bord de dalle:BP
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: BP

# IfcBuildingElementProxy: Bord de dalle:dalle de transition (2)
Pset_BuildingElementProxyCommon - Reference: dalle de transition
Name (Bord de dalle:...) | In
dalle de transition | Niveau 1
dalle de transition | Niveau 2

# IfcBuildingElementProxy: Bord de dalle:dalle inférieure
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: dalle inférieure

# IfcBuildingElementProxy: Bord de dalle:dalle supérieure
In: Niveau 2
Pset_BuildingElementProxyCommon - Reference: dalle supérieure

# IfcBuildingElementProxy: Bord de dalle:pied droit
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: pied droit

# IfcBuildingElementProxy: Bord de dalle:pied droit 2
In: Niveau 1
Pset_BuildingElementProxyCommon - Reference: pied droit 2
